## Kconfig
```kconfig
config USR_DRV_SDIO
  bool  "userspace SDIO driver"
  default y
  ---help---
  Support for STM32F4 SDIO hardware IP.
```
